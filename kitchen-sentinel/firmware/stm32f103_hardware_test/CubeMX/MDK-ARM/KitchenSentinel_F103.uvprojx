# Keil uVision project KitchenSentinel_F103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x0000A000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -J..\Drivers\CompilerHeaders
  c include: ..\Drivers\CompilerHeaders;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers;..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../Core/Src/: main.c stm32f1xx_it.c demo.c sensor_processing.c kitchen_wifi.c oled_dashboard.c supply_monitor.c response_policy.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Core/Inc/: kitchen_wifi.h oled_glyphs.h oled_dashboard.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/ATK_OLED/: atk_oled.c
    ../Drivers/BSP/ATK_MB026/: atk_mb026.c atk_mb026_uart.c
  group Readme
    ../: readme.txt
  group Project headers and device support
    ../Core/Inc/: demo.h hardware_control.h hardware_status.h network_config.h supply_monitor.h response_policy.h sensor_processing.h stm32f1xx_hal_conf.h stm32f1xx_it.h test_config.h
    ../DeviceSupport/Include/: stm32f10x.h system_stm32f10x.h
  group Local HAL CMSIS BSP and C headers
    ../Drivers/BSP/ATK_MB026/: atk_mb026.h atk_mb026_uart.h
    ../Drivers/BSP/ATK_OLED/: atk_oled.h oledfont.h
    ../Drivers/BSP/IIC/: myiic.h
    ../Drivers/BSP/KEY/: key.h
    ../Drivers/BSP/LED/: led.h
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h
    ../Drivers/CompilerHeaders/: math.h stdarg.h stddef.h stdint.h stdio.h stdlib.h string.h
    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cec.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_usb.h
    ../Drivers/SYSTEM/delay/: delay.h
    ../Drivers/SYSTEM/sys/: sys.h
    ../Drivers/SYSTEM/usart/: usart.h
  group Offline storage and CubeMX configuration
    ../Core/Src/: sample_spool.c
    ../Core/Inc/: sample_spool.h
    ../: KitchenSentinel_F103.ioc
target Download (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: atk_f103 +hex
  AfterMake: "..\..\..\..\.venv\Scripts\python.exe" -X utf8 ..\tools\keil_download.py
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -J..\Drivers\CompilerHeaders
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x5000
